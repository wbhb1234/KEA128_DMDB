# Keil uVision project kea128_dmdb.uvprojx, settings and files
target kea128_dmdb_main (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: kea128_dmdb
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Headers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Sources
    ./Sources/: ADC.c CLK.c FTM.c main.c UART.c PWT.c
  group Header
    ./Headers/: ADC.h CLK.h derivative.h FTM.h typedefs.h UART.h PWT.h
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
